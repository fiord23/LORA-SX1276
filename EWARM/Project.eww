<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L151 LORA.ewp</path>
  </project>
  <batchBuild />
</workspace>
